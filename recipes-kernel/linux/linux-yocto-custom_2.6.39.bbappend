FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_yourmachine = "at91sam9x25ek|ariag25"
